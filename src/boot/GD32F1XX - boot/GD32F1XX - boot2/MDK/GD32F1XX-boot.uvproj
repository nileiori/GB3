# Keil uVision project GD32F1XX-boot.uvproj, settings and files
target GD32F1XX (ARM-ADS)
  device: GD32F105ZE GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GD32F1XX +hex
  AfterMake: d:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/GD32F1XX.bin ./obj/GD32F1XX.axf
  c flags: Optim=1 oTime=1
  c include: ..\LIB\STM32F10x_StdPeriph_Driver\inc;..\USER;..\LIB\CMSIS\Core\CM3\startup\arm;..\LIB\CMSIS\Core\CM3;..\LIB\FAT_FS\inc;..\LIB\USB_App\inc;..\LIB\USB_Driver\inc;..\LIB\USB_Lib\Library\Class\MSC\inc;..\LIB\USB_Lib\Library\Core\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../USER/: main.c stm32f10x_it.c spi_flash.c spi_flash_app.c E2prom_25LC320A.c crc.c
  group LIB
    ../LIB/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../LIB/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../LIB/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
