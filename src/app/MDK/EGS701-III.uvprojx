# Keil uVision project EGS701-III.uvprojx, settings and files
target EGS701-III (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F105ZE GigaDevice
  pack: Keil.GD32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EGS701-III
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output ./bin/EGS701-III.bin ./obj/EGS701-III.axf
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,EYE_MODEM,EYE_EGS701,TTS_MODEM
  c misc: --diag_suppress=1
  c include: ..\CMSIS\Core\CM3\startup\arm;..\CMSIS\Core\CM3;..\src;..\src\MODEM;..\src\PRINT;..\src\VDR;..\..\..\lib\FAT_FS\src;..\..\..\lib\FAT_FS\src\option;..\..\..\lib\FAT_FS\inc;..\..\..\lib\STM32F10x_StdPeriph_Driver\src;..\..\..\lib\STM32F10x_StdPeriph_Driver\inc;..\..\..\lib\USB_App\inc;..\..\..\lib\USB_App\src;..\..\..\lib\USB_Driver\inc;..\..\..\lib\USB_Driver\src;..\..\..\lib\USB_Lib\Library\Class\MSC;..\..\..\lib\USB_Lib\Library\Core\src;..\..\..\lib\USB_Lib\Library\Core\inc;..\..\..\lib\USB_Lib\Library\Class\MSC\src;..\..\..\lib\USB_Lib\Library\Class\MSC\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x8004000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../src/: A2_OBD.c Acceleration.c Adc.c adc_key.c adc_tran_voltag.c AreaManage.c Blind.c Bma250.c BMA250E.c Camera_App.c Camera_Driver.c Can_App.c Can_Driver.c Card.c comm.c Corner.c crypt.c DeepPlow.c downloadGB2313.c E2ParamApp.c E2prom_25LC320A.c EepromPram.c EeyeLib.c EIExpand.c ESpin.c fm25c160.c Gdi.c Gnss_app.c GPIOControl.c Gps_App.c Gps_Driver.c HeartBeat.c I2C.c ICCARD_E2.c ICCARD_M3.c Io.c JointechOiL_Protocol.c Lcd.C lcd_driver.C Load_detection.c Lock1.c Lock2.c logprintf.c LzmSys.c main.c Media.c MediaSearch.c Menu.c Message.c MileMeter.c mmc_sd.c NaviLcd.c OilControl.c other.c PacketUpdate.c Phone.c PhoneBook.c Photo.c Polygon.c Public.c queue.c RadioProtocol.c Report.c route.c rtc.c Sleep.c SleepDeep.c spi.c spi_flash.c Spin.c StatusAlarm.c SystemInit.c SysTickApp.c TaskMenu.c taskschedule.c temperature.c timer.c TTSDevApp.c TTSDevDrv.c turnspeed.c Usart_drive.c Usart1.c Usart2.c Usart3.c Vss.c
    ../CMSIS/Core/CM3/: stm32f10x_it.c
  group CMSIS
    ../CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ../CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group USB_Driver
    ../../../lib/USB_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_Lib
    ../../../lib/USB_Lib/Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../../../lib/USB_Lib/Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group USB_App
    ../../../lib/USB_App/src/: usb_app.c usb_bsp.c usbh_usr.c
  group FAT_FS
    ../../../lib/FAT_FS/src/: fattime.c ff.c
    ../../../lib/FAT_FS/src/option/: ccsbcs.c
  group STM32F10x_Lib
    ../../../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MODEM
    ../src/MODEM/: modem_api.c modem_app_com.c modem_app_first.c modem_app_other.c modem_app_second.c modem_bsp.c modem_core.c modem_debug.c modem_lib.c modem_port.c modem_state.c modem_uart.c
  group VDR
    ../src/VDR/: VDR_Card.c VDR_Coefficient.c VDR_Data.c VDR_Docimasy.c VDR_Doubt.c VDR_Gprs.c VDR_Log.c VDR_Overspeed.c VDR_Overtime.c VDR_Parameter.c VDR_Position.c VDR_Power.c VDR_Protocol.c VDR_Pub.c VDR_Pulse.c VDR_Speed.c VDR_SpeedStatus.c VDR_Usart.c VDR_Usb.c
  group PRINT
    ../src/PRINT/: b_queue.c font.c printer.c printer_test.c ptr_stepmotor_ctrl.c ptr_temperature.c ptr_timer.c
